options:
  parameters:
    generate_options: qt_gui
    id: aaa
    output_language: python
    title: workshop 4.3b
  states: {}

blocks:
- name: amp_gain
  id: variable_qtgui_range
  parameters:
    label: Amp Gain
    start: '-3'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: avg_win_len
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '100'
  states: {}
- name: avg_win_len_0
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '100'
  states: {}
- name: bps
  id: variable
  parameters:
    value: cons_obj.bits_per_symbol()
  states: {}
- name: cons_obj
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: damp_factor_symbol_sync
  id: variable_qtgui_range
  parameters:
    label: damp_factor_symbol_sync
    start: '0'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: duration_ms
  id: variable
  parameters:
    value: '50'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 915* 1000000
  states: {}
- name: header_format
  id: variable
  parameters:
    value: digital.header_format_default(preamble, threshold, bps)
  states: {}
- name: loop_bw_costas
  id: variable_qtgui_range
  parameters:
    label: loop_bw_costas
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.035'
  states: {}
- name: loop_bw_symbol_sync
  id: variable_qtgui_range
  parameters:
    label: loop_bw_symbol_sync
    start: '0'
    step: '0.001'
    stop: '0.5'
    value: '0.0157'
  states: {}
- name: mark_delay
  id: variable_qtgui_range
  parameters:
    label: mark_delay
    rangeType: int
    start: '0'
    step: '1'
    stop: '40'
    value: '1'
  states: {}
- name: modulated_sync_word
  id: variable
  parameters:
    value: np.array([ 6.3415498e-01+0.j, -8.2522854e-02+0.j, -6.7432624e-01+0.j, 2.1960361e-02+0.j,  6.6994393e-01+0.j,  2.7926212e-02+0.j, -6.2773204e-01+0.j, -1.6468078e-01+0.j,  5.7718420e-01+0.j, 7.2756535e-01+0.j,  4.6373290e-01+0.j,  2.3871353e-02+0.j, -4.8910391e-01+0.j, -7.3612314e-01+0.j, -4.8162562e-01+0.j, 1.2282493e-02+0.j,  4.6576929e-01+0.j,  7.3573601e-01+0.j, 5.4807413e-01+0.j, -1.3198391e-01+0.j, -5.6807721e-01+0.j, -1.1599341e-01+0.j,  6.0297143e-01+0.j,  6.1259979e-01+0.j, 3.7387580e-01+0.j,  6.1534089e-01+0.j,  6.1044985e-01+0.j, -1.3032347e-01+0.j, -5.7351917e-01+0.j, -1.1359498e-01+0.j, 5.1318854e-01+0.j,  7.6605660e-01+0.j,  5.5351597e-01+0.j, -1.7184576e-01+0.j, -6.0304552e-01+0.j, -5.2386895e-09+0.j, 6.0304564e-01+0.j,  1.7458701e-01+0.j, -5.4603779e-01+0.j, -7.7764541e-01+0.j, -5.1115209e-01+0.j,  1.2587748e-01+0.j, 5.5562639e-01+0.j,  1.4426640e-01+0.j, -5.5147964e-01+0.j, -7.4326605e-01+0.j, -4.9114031e-01+0.j,  2.7579335e-02+0.j, 5.3652304e-01+0.j,  5.9185678e-01+0.j,  4.3005973e-01+0.j, 5.5639654e-01+0.j,  5.7140875e-01+0.j,  1.4330061e-02+0.j, -5.7344508e-01+0.j, -5.8026785e-01+0.j, -4.0265229e-01+0.j, -6.0784715e-01+0.j, -6.1882788e-01+0.j,  1.3541880e-01+0.j, 6.3996756e-01+0.j, -1.1588858e-02+0.j, -6.3045293e-01+0.j, -1.2313626e-01+0.j,  5.9345692e-01+0.j,  6.3337904e-01+0.j, 4.5958614e-01+0.j,  4.4280154e-01+0.j,  4.8155165e-01+0.j, 6.0579962e-01+0.j,  5.2610868e-01+0.j,  2.5531810e-02+0.j, -4.9454585e-01+0.j, -7.3372471e-01+0.j, -5.7140863e-01+0.j, 1.6025695e-01+0.j,  6.3045293e-01+0.j, -2.2790564e-02+0.j, -6.5453744e-01+0.j, -4.3920707e-02+0.j,  6.6330218e-01+0.j, 1.3472509e-01+0.j, -6.3582081e-01+0.j, -5.8741081e-01+0.j, -4.1216698e-01+0.j, -5.9255040e-01+0.j, -5.4807413e-01+0.j, -1.3942933e-02+0.j,  5.0699669e-01+0.j,  7.0545167e-01+0.j, 5.1991683e-01+0.j, -3.5073120e-02+0.j, -5.2814502e-01+0.j, -5.9695208e-01+0.j, -4.9650821e-01+0.j, -4.3669510e-01+0.j, -4.6910083e-01+0.j, -6.3407266e-01+0.j, -5.7760048e-01+0.j, 9.9652052e-02+0.j,  5.9685379e-01+0.j,  1.1398210e-01+0.j, -5.7963693e-01+0.j, -6.4087272e-01+0.j, -4.3625149e-01+0.j, -4.7107458e-01+0.j, -5.4392737e-01+0.j, -4.6153325e-01+0.j, -4.5958611e-01+0.j, -6.1738855e-01+0.j, -5.3855950e-01+0.j, 2.7412227e-03+0.j,  5.4603767e-01+0.j,  6.0305846e-01+0.j, 4.5414424e-01+0.j,  4.7992218e-01+0.j,  5.0904173e-01+0.j, 4.9728334e-01+0.j,  5.1278079e-01+0.j,  4.7549835e-01+0.j, 4.5890158e-01+0.j,  6.0340530e-01+0.j,  5.3810960e-01+0.j, 1.3112724e-02+0.j, -5.2549899e-01+0.j, -6.6004950e-01+0.j, -4.8329139e-01+0.j, -2.2242454e-01+0.j], dtype=np.complex64)
  states: {}
- name: modulated_sync_word_q2
  id: variable
  parameters:
    value: np.array([-0.449+0.449j, -0.660+0.454j, -0.449+0.449j, 0.166+0.585j, 0.449+0.449j, -0.009+-0.149j, -0.449+-0.449j, -0.147+0.052j, 0.449+0.449j, 0.623+-0.016j, 0.449+-0.449j, 0.357+-0.014j, 0.449+0.449j, 0.558+0.065j, 0.449+-0.449j, 0.049+-0.195j, -0.449+0.449j, -0.716+0.698j, -0.449+0.449j, 0.195+-0.009j, 0.449+-0.449j, -0.049+-0.638j, -0.449+-0.449j, -0.039+-0.011j, 0.449+0.449j, 0.144+0.686j, -0.449+0.449j, -0.568+-0.144j, -0.449+-0.449j, -0.494+-0.080j, -0.449+0.449j, -0.051+0.541j, 0.449+0.449j, 0.665+0.545j, 0.449+0.449j, -0.041+-0.086j, -0.449+-0.449j, -0.556+-0.159j, -0.449+0.449j, -0.359+0.755j, -0.449+0.449j, -0.609+-0.201j, -0.449+-0.449j, 0.105+-0.002j, 0.449+0.449j, 0.111+0.201j, -0.449+-0.449j, -0.593+-0.753j, -0.449+-0.449j, -0.408+0.146j, -0.449+0.449j, -0.424+0.132j, -0.449+-0.449j, -0.556+-0.702j, -0.449+-0.449j, 0.013+0.064j, 0.449+0.449j, 0.512+0.499j, 0.449+0.449j, 0.537+0.535j, 0.449+0.449j, -0.040+-0.040j, -0.449+-0.449j, -0.331+-0.331j],dtype=np.complex64)
  states: {}
- name: modulated_sync_word_q4
  id: variable
  parameters:
    value: np.array([(-0.3236511+0.38326213j) ,(-0.40872774+0.4129707j) ,(-0.4845583+0.37997225j) ,(-0.5032182+0.32404065j) ,(-0.41165453+0.29910493j) ,(-0.19140323+0.3406076j) ,(0.10448951+0.42875668j) ,(0.35776585+0.48820764j) ,(0.43999088+0.43321377j) ,(0.29857585+0.2238044j) ,(-0.0016923123-0.08678568j) ,(-0.30493987-0.36322355j) ,(-0.4475175-0.4616031j) ,(-0.3578216-0.31402352j) ,(-0.09209495+0.014918805j) ,(0.21060005+0.34843063j) ,(0.42208895+0.48991635j) ,(0.4896213+0.3480378j) ,(0.4486313-0.0024159108j) ,(0.37551832-0.35752875j) ,(0.3248284-0.5023269j) ,(0.30946657-0.34937963j) ,(0.31296533+0.0067436444j) ,(0.32001734+0.35203642j) ,(0.34035328+0.48583436j) ,(0.38160172+0.33988425j) ,(0.42816985+0.013239303j) ,(0.4384216-0.30044156j) ,(0.37184545-0.44174817j) ,(0.22137748-0.35834423j) ,(0.01804548-0.11132968j) ,(-0.185752+0.18075284j) ,(-0.34953737+0.40530214j) ,(-0.46069875+0.51281655j) ,(-0.5185853+0.5132632j) ,(-0.51158166+0.44026196j) ,(-0.40386286+0.3277593j) ,(-0.1798393+0.18640213j) ,(0.11326713+0.01687191j) ,(0.3639046-0.16836074j) ,(0.4455944-0.3456911j) ,(0.29753157-0.47543958j) ,(-0.016108027-0.52028054j) ,(-0.32668304-0.4689656j) ,(-0.46261698-0.3404056j) ,(-0.34330258-0.17003584j) ,(-0.031042483+0.008681094j) ,(0.30258363+0.17916662j) ,(0.46881175+0.32919857j) ,(0.38078758+0.44964597j) ,(0.09522163+0.52000684j) ,(-0.23234767+0.50608927j) ,(-0.44938833+0.38737035j) ,(-0.49435654+0.17034389j) ,(-0.41517287-0.09328418j) ,(-0.3205732-0.31230974j) ,(-0.29131326-0.40150824j) ,(-0.34087446-0.3159915j) ,(-0.41880548-0.08198235j) ,(-0.45265406+0.2069943j) ,(-0.38737032+0.42617095j) ,(-0.22377913+0.49777487j) ,(-0.009854655+0.43297607j) ,(0.19706434+0.31843114j) ,(0.35833743+0.26424968j) ,(0.45907328+0.3184311j) ,(0.4986024+0.4349135j) ,(0.47110766+0.5042489j) ,(0.3674692+0.4314565j) ,(0.19247924+0.20531921j) ,(-0.024789115-0.09211061j) ,(-0.23076144-0.32970107j) ,(-0.37328473-0.40535447j) ,(-0.431186-0.30125067j) ,(-0.42191654-0.08028718j) ,(-0.38640052+0.16437826j) ,(-0.3509243+0.3627137j) ,(-0.3248162+0.4879715j) ,(-0.30864936+0.54143703j) ,(-0.30870503+0.5161171j) ,(-0.3315532+0.39121655j) ,(-0.3832272+0.1629665j) ,(-0.44815278-0.12145794j) ,(-0.4788955-0.35594255j) ,(-0.40823913-0.42622328j) ,(-0.20873754-0.28620908j) ,(0.07043252+6.0535967e-09j) ,(0.31889516+0.2862091j) ,(0.42184705+0.4262233j) ,(0.32704428+0.35594258j) ,(0.08056081+0.12339542j) ,(-0.20150197-0.15649253j) ,(-0.40967843-0.38593107j) ,(-0.4882795-0.5177922j) ,(-0.452959-0.5496278j) ,(-0.370026-0.49520707j) ,(-0.30833587-0.36127442j) ,(-0.2999712-0.15499425j) ,(-0.33294827+0.08896827j) ,(-0.3716122+0.30099744j) ,(-0.38443947+0.39270815j) ,(-0.36314175+0.31761697j) ,(-0.32814205+0.10196527j) ,(-0.3122589-0.16652036j) ,(-0.33011392-0.38977727j) ,(-0.37752494-0.51041484j) ,(-0.42913863-0.52436024j) ,(-0.44573534-0.46128526j) ,(-0.38472754-0.3444876j) ,(-0.2282984-0.18226397j) ,(-0.0016794971+0.016365988j) ,(0.23333398+0.22292504j) ,(0.40050048+0.38256863j) ,(0.45461327+0.44788605j) ,(0.40987924+0.4166229j) ,(0.32967448+0.33905846j) ,(0.29163128+0.29307055j) ,(0.33206883+0.32483327j) ,(0.41890198+0.41071117j) ,(0.47003168+0.46835655j) ,(0.41165453+0.41694003j) ,(0.22458975+0.23106374j) ,(-0.038833216-0.03689576j)],dtype=np.complex64)
  states: {}
- name: modulated_sync_wordq
  id: variable
  parameters:
    value: np.array([-0.449+0.449j, -0.660+0.454j, -0.449+0.449j, 0.166+0.585j, 0.449+0.449j, -0.009+-0.149j, -0.449+-0.449j, -0.147+0.052j, 0.449+0.449j, 0.623+-0.016j, 0.449+-0.449j, 0.357+-0.014j, 0.449+0.449j, 0.558+0.065j, 0.449+-0.449j, 0.049+-0.195j, -0.449+0.449j, -0.716+0.698j, -0.449+0.449j, 0.195+-0.009j, 0.449+-0.449j, -0.049+-0.638j, -0.449+-0.449j, -0.039+-0.011j, 0.449+0.449j, 0.144+0.686j, -0.449+0.449j, -0.568+-0.144j, -0.449+-0.449j, -0.494+-0.080j, -0.449+0.449j, -0.051+0.541j, 0.449+0.449j, 0.665+0.545j, 0.449+0.449j, -0.041+-0.086j, -0.449+-0.449j, -0.556+-0.159j, -0.449+0.449j, -0.359+0.755j, -0.449+0.449j, -0.609+-0.201j, -0.449+-0.449j, 0.105+-0.002j, 0.449+0.449j, 0.111+0.201j, -0.449+-0.449j, -0.593+-0.753j, -0.449+-0.449j, -0.408+0.146j, -0.449+0.449j, -0.424+0.132j, -0.449+-0.449j, -0.556+-0.702j, -0.449+-0.449j, 0.013+0.064j, 0.449+0.449j, 0.512+0.499j, 0.449+0.449j, 0.537+0.535j, 0.449+0.449j, -0.040+-0.040j, -0.449+-0.449j, -0.331+-0.331j],dtype=np.complex64)
  states: {}
- name: n_chan
  id: variable
  parameters:
    value: '2'
  states: {}
- name: n_chan_0
  id: variable
  parameters:
    value: '2'
  states: {}
- name: nbytes
  id: variable
  parameters:
    value: '16'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: preamble
  id: variable
  parameters:
    value: digital.packet_utils.default_access_code
  states: {}
- name: randomize
  id: variable_qtgui_chooser
  parameters:
    label: Randomize
    label0: 'False'
    label1: 'True'
    num_opts: '2'
    option0: '0'
    option1: 'True'
    type: raw
    value: 'False'
  states: {}
- name: rf_freq
  id: variable_qtgui_range
  parameters:
    label: RF Frequency
    start: 70e6
    step: 1e3
    stop: 6e9
    value: 915e6
    widget: counter
  states: {}
- name: rrc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: excess_bw
    gain: nfilts
    ntaps: 11*sps*nfilts
    samp_rate: sps*nfilts
    sym_rate: '1.0'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: rx_gain
    start: '0'
    step: '1'
    stop: '60'
    value: '30'
  states: {}
- name: rx_gain_0
  id: variable_qtgui_range
  parameters:
    label: Rx Gain (dB)
    start: '-15'
    step: '1'
    stop: '60'
    value: '30'
    widget: counter
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: symb_rate * sps
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: scenario
  id: variable_qtgui_range
  parameters:
    label: Scenario
    rangeType: int
    start: '0'
    step: '1'
    stop: 2**n_chan - 1
    value: 2**n_chan - 1
    widget: counter
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: symb_rate
  id: variable
  parameters:
    value: 400* 1000
  states: {}
- name: taps_resampler
  id: variable
  parameters:
    value: filter.firdes.low_pass(1, n_chan*samp_rate, 0.49e6, 100e3)
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '5'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: tx_gain
    rangeType: int
    start: '0'
    step: '1'
    stop: '66'
    value: '66'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '500000'
    offset: '0'
    phase: '0'
    samp_rate: n_chan*samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-500000'
    offset: '0'
    phase: '0'
    samp_rate: n_chan*samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: bladeRF_source_0
  id: bladeRF_source
  parameters:
    bias_tee0: 'False'
    bias_tee1: 'False'
    bw: '0'
    dac: '10000'
    dc_calibration: LPF_TUNING
    dc_offset_mode0: '0'
    dc_offset_mode1: '0'
    device_id: 991431a963384f8289baea2ba586720d
    fpga_image: ''
    fpga_reload: 'False'
    freq: rf_freq
    gain0: rx_gain
    gain1: '10'
    gain_mode0: 'False'
    gain_mode1: 'False'
    if_gain0: '0'
    if_gain1: '20'
    in_clk: ONBOARD
    iq_balance_mode0: '0'
    iq_balance_mode1: '0'
    lpf_mode: disabled
    metadata: 'False'
    nchan: '1'
    out_clk: 'False'
    ref_clk: 10e6
    sample_rate: n_chan_0*samp_rate_0
    sampling: internal
    show_pmic: 'False'
    smb: '0'
    tamer: internal
    trigger0: 'False'
    trigger1: 'False'
    trigger_role0: master
    trigger_role1: master
    trigger_signal0: J51_1
    trigger_signal1: J51_1
    use_dac: 'False'
    verbosity: warning
    xb200: none
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.PMT_NIL, pmt.make_u8vector(nbytes, 0x00))
    period: '10'
  states: {}
- name: blocks_message_strobe_0_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.PMT_NIL, pmt.make_u8vector(nbytes, 0x00))
    period: '10'
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: avg_win_len
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: avg_win_len
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.25'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.25'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '64'
    type: byte
  states: {state: bypassed}
- name: blocks_stream_to_tagged_stream_0_1
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '64'
    type: byte
  states: {state: bypassed}
- name: blocks_stream_to_tagged_stream_1
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '64'
    type: byte
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_1_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '64'
    type: byte
  states: {state: disabled}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: n_chan*samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (57, 12, 140, 125, 114, 71, 52, 44, 216, 16, 15, 47, 111, 119, 13, 101, 214, 112, 229, 142, 3, 81, 216, 174, 142, 79, 110, 172, 52, 47, 194, 49, 183, 176, 135, 22, 235, 63, 193, 40, 150, 185, 98, 35, 23, 116, 148, 40, 119, 51, 194, 142, 232, 186, 83, 189, 181, 107, 136, 36, 87, 125, 83, 236)
  states: {state: disabled}
- name: blocks_vector_source_x_0_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (57, 12, 140, 125, 114, 71, 52, 44, 216, 16, 15, 47, 111, 119, 13, 101, 214, 112, 229, 142, 3, 81, 216, 174, 142, 79, 110, 172, 52, 47, 194, 49, 183, 176, 135, 22, 235, 63, 193, 40, 150, 185, 98, 35, 23, 116, 148, 40, 119, 51, 194, 142, 232, 186, 83, 189, 181, 107, 136, 36, 87, 125, 83, 236)
  states: {state: disabled}
- name: cdc_bladeRF_sink_0
  id: cdc_bladeRF_sink
  parameters:
    buffers: '16'
    buflen: '8192'
    bw: 1e6
    device_id: 38306da1e3964066ad646c0a2b56e27a
    freq: freq
    gain0: tx_gain
    gain1: '10'
    metadata: 'False'
    nchan: '1'
    sample_rate: samp_rate
    transfers: '8'
    verbosity: warning
  states: {state: disabled}
- name: cdc_bladeRF_sink_0_0
  id: cdc_bladeRF_sink
  parameters:
    buffers: '16'
    buflen: '8192'
    bw: 2e6
    device_id: 991431a963384f8289baea2ba586720d
    freq: freq
    gain0: tx_gain
    gain1: '10'
    metadata: 'False'
    nchan: '1'
    sample_rate: samp_rate*2
    transfers: '8'
    verbosity: warning
  states: {}
- name: cdc_bladeRF_sink_0_1
  id: cdc_bladeRF_sink
  parameters:
    buffers: '16'
    buflen: '8192'
    bw: 1e6
    device_id: 38306da1e3964066ad646c0a2b56e27a
    freq: freq
    gain0: tx_gain
    gain1: '10'
    metadata: 'False'
    nchan: '1'
    sample_rate: samp_rate
    transfers: '8'
    verbosity: warning
  states: {state: disabled}
- name: digital_additive_scrambler_bb_0_0_0
  id: digital_additive_scrambler_bb
  parameters:
    bits_per_byte: '8'
    count: '0'
    len: '7'
    mask: '0x8A'
    reset_tag_key: '"packet_len"'
    seed: '0x7F'
  states: {}
- name: digital_additive_scrambler_bb_0_0_0_0
  id: digital_additive_scrambler_bb
  parameters:
    bits_per_byte: '8'
    count: '0'
    len: '7'
    mask: '0x8A'
    reset_tag_key: '"packet_len"'
    seed: '0x7F'
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: cons_obj
    differential: 'False'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: cons_obj
    differential: 'False'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_crc32_async_bb_0
  id: digital_crc32_async_bb
  parameters:
    check: 'False'
  states: {}
- name: digital_crc32_async_bb_0_0
  id: digital_crc32_async_bb
  parameters:
    check: 'False'
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {state: disabled}
- name: digital_crc32_bb_1
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {state: disabled}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: header_format
    len_tag_key: '"packet_len"'
  states: {}
- name: digital_protocol_formatter_bb_0_0
  id: digital_protocol_formatter_bb
  parameters:
    format: header_format
    len_tag_key: '"packet_len"'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    PMT_msg: pmt.cons(pmt.PMT_NIL, pmt.make_u8vector(nbytes, 0xFF))
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block

          def __init__(self, threshold=20, samp_rate = 32000, step_window=1600, samp_window=160, msg_window=1280,  PMT_msg = pmt.cons(pmt.PMT_NIL, pmt.make_u8vector(16,0x00))):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Energy detection Block',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.threshold = threshold
              self.samp_rate = samp_rate
              self.step_window = step_window
              self.samp_window = samp_window
              self.msg_window = msg_window
              self.PMT_msg = PMT_msg
              self.portName = 'msg_out'
              self.message_port_register_out(pmt.intern(self.portName))
              self.timer = 0
              self.counter = 0
              self.readyForTag = True
              self.readyForMSG = False

          def work(self, input_items, output_items):
          	for index in range(len(input_items[0])):
          		if (input_items[0][index] <= self.threshold and self.readyForTag == True):
          			key = pmt.intern('detect')
          			value = pmt.from_float(np.round(float(input_items[0][index]),2))
          			writeIndex = self.nitems_written(0) + index
          			self.add_item_tag(0, writeIndex, key, value )
          			self.readyForTag = False
          			self.readyForMSG = True
          			##### send message #####
          			#PMT_msg = pmt.cons(pmt.PMT_NIL, pmt.make_u8vector(16,0x00))
          			self.message_port_pub(pmt.intern(self.portName), self.PMT_msg)
          			
          		# increase the timer by 1
          		if (self.readyForTag == False):
          			self.timer = self.timer + 1
          		if (self.readyForMSG == True):
          			self.counter = self.counter + 1
          			
          		# set flag to write
          		if (self.timer >= (self.step_window*self.samp_rate/1000)):
          			# reset timer
          			self.timer = 0
          			# reset state once timer hits max value
          			self.readyForTag = True
          		if (self.counter >= (self.samp_window*self.samp_rate/1000)):
          			# reset timer
          			self.counter = 0
          			key = pmt.intern('msg')
          			value = pmt.from_float(np.round(float(input_items[0][index]),2))
          			writeIndex = self.nitems_written(0) + index
          			self.add_item_tag(0, writeIndex, key, value )
          			self.message_port_pub(pmt.intern(self.portName), self.PMT_msg)
          		if (self.timer >= (self.msg_window*self.samp_rate/1000)):
          			# reset state once timer hits max value
          			self.readyForMSG = False
          		
          	output_items[0][:] = input_items[0]
          	return len(output_items[0])
    msg_window: '40'
    samp_rate: samp_rate_0
    samp_window: '5'
    step_window: '50'
    threshold: '9e-6'
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    PMT_msg: pmt.cons(pmt.PMT_NIL, pmt.make_u8vector(nbytes, 0xFF))
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block

          def __init__(self, threshold=20, samp_rate = 32000, step_window=1600, samp_window=160, msg_window=1280,  PMT_msg = pmt.cons(pmt.PMT_NIL, pmt.make_u8vector(16,0x00))):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Energy detection Block',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.threshold = threshold
              self.samp_rate = samp_rate
              self.step_window = step_window
              self.samp_window = samp_window
              self.msg_window = msg_window
              self.PMT_msg = PMT_msg
              self.portName = 'msg_out'
              self.message_port_register_out(pmt.intern(self.portName))
              self.timer = 0
              self.counter = 0
              self.readyForTag = True
              self.readyForMSG = False

          def work(self, input_items, output_items):
          	for index in range(len(input_items[0])):
          		if (input_items[0][index] <= self.threshold and self.readyForTag == True):
          			key = pmt.intern('detect')
          			value = pmt.from_float(np.round(float(input_items[0][index]),2))
          			writeIndex = self.nitems_written(0) + index
          			self.add_item_tag(0, writeIndex, key, value )
          			self.readyForTag = False
          			self.readyForMSG = True
          			##### send message #####
          			#PMT_msg = pmt.cons(pmt.PMT_NIL, pmt.make_u8vector(16,0x00))
          			self.message_port_pub(pmt.intern(self.portName), self.PMT_msg)
          			
          		# increase the timer by 1
          		if (self.readyForTag == False):
          			self.timer = self.timer + 1
          		if (self.readyForMSG == True):
          			self.counter = self.counter + 1
          			
          		# set flag to write
          		if (self.timer >= (self.step_window*self.samp_rate/1000)):
          			# reset timer
          			self.timer = 0
          			# reset state once timer hits max value
          			self.readyForTag = True
          		if (self.counter >= (self.samp_window*self.samp_rate/1000)):
          			# reset timer
          			self.counter = 0
          			key = pmt.intern('msg')
          			value = pmt.from_float(np.round(float(input_items[0][index]),2))
          			writeIndex = self.nitems_written(0) + index
          			self.add_item_tag(0, writeIndex, key, value )
          			self.message_port_pub(pmt.intern(self.portName), self.PMT_msg)
          		if (self.timer >= (self.msg_window*self.samp_rate/1000)):
          			# reset state once timer hits max value
          			self.readyForMSG = False
          		
          	output_items[0][:] = input_items[0]
          	return len(output_items[0])
    msg_window: '40'
    samp_rate: samp_rate_0
    samp_window: '5'
    step_window: '50'
    threshold: '9e-6'
  states: {}
- name: epy_block_2_0
  id: epy_block
  parameters:
    PMT_msg: pmt.cons(pmt.PMT_NIL, pmt.make_u8vector(nbytes, 0xFF))
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block

          def __init__(self, threshold=20, samp_rate = 32000, step_window=1600, samp_window=160, msg_window=1280,  PMT_msg = pmt.cons(pmt.PMT_NIL, pmt.make_u8vector(16,0x00))):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Energy detection Block',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.threshold = threshold
              self.samp_rate = samp_rate
              self.step_window = step_window
              self.samp_window = samp_window
              self.msg_window = msg_window
              self.PMT_msg = PMT_msg
              self.portName = 'msg_out'
              self.message_port_register_out(pmt.intern(self.portName))
              self.timer = 0
              self.counter = 0
              self.readyForTag = True
              self.readyForMSG = False

          def work(self, input_items, output_items):
          	for index in range(len(input_items[0])):
          		if (input_items[0][index] <= self.threshold and self.readyForTag == True):
          			key = pmt.intern('detect')
          			value = pmt.from_float(np.round(float(input_items[0][index]),2))
          			writeIndex = self.nitems_written(0) + index
          			self.add_item_tag(0, writeIndex, key, value )
          			self.readyForTag = False
          			self.readyForMSG = True
          			##### send message #####
          			#PMT_msg = pmt.cons(pmt.PMT_NIL, pmt.make_u8vector(16,0x00))
          			self.message_port_pub(pmt.intern(self.portName), self.PMT_msg)
          			
          		# increase the timer by 1
          		if (self.readyForTag == False):
          			self.timer = self.timer + 1
          		if (self.readyForMSG == True):
          			self.counter = self.counter + 1
          			
          		# set flag to write
          		if (self.timer >= (self.step_window*self.samp_rate/1000)):
          			# reset timer
          			self.timer = 0
          			# reset state once timer hits max value
          			self.readyForTag = True
          		if (self.counter >= (self.samp_window*self.samp_rate/1000)):
          			# reset timer
          			self.counter = 0
          			key = pmt.intern('msg')
          			value = pmt.from_float(np.round(float(input_items[0][index]),2))
          			writeIndex = self.nitems_written(0) + index
          			self.add_item_tag(0, writeIndex, key, value )
          			self.message_port_pub(pmt.intern(self.portName), self.PMT_msg)
          		if (self.timer >= (self.msg_window*self.samp_rate/1000)):
          			# reset state once timer hits max value
          			self.readyForMSG = False
          		
          	output_items[0][:] = input_items[0]
          	return len(output_items[0])
    msg_window: '40'
    samp_rate: samp_rate_0
    samp_window: '5'
    step_window: '50'
    threshold: '9e-6'
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: samp_rate_0/2
    decim: n_chan
    nthreads: '4'
    samp_rate: n_chan_0*samp_rate_0
    taps: filter.firdes.low_pass(1, n_chan*samp_rate, 0.49e6, 0.1e6)
  states: {}
- name: freq_xlating_fft_filter_ccc_0_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: '-samp_rate_0/2'
    decim: n_chan
    nthreads: '4'
    samp_rate: n_chan_0*samp_rate_0
    taps: filter.firdes.low_pass(1, n_chan*samp_rate, 0.49e6, 0.1e6)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: n_chan*samp_rate
    fc: rf_freq
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: n_chan*samp_rate
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_3
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: Signal
    label2: Averaged
    name: '"Average power"'
    nconnections: '3'
    size: '320000'
    srate: samp_rate
    type: float
    ymax: '3'
    ymin: '0'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '2'
    taps: taps_resampler
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '2'
    taps: taps_resampler
    type: ccc
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: MSG_ch1
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: MSG_ch2
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: chan1
  states: {}
- name: virtual_sink_1_1
  id: virtual_sink
  parameters:
    stream_id: chan2
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: MSG_ch1
  states: {state: disabled}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: chan2
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: chan1
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: MSG_ch2
  states: {state: disabled}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:95000
    timeout: '100'
    type: complex
  states: {state: disabled}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:95000
    timeout: '100'
    type: complex
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [bladeRF_source_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [bladeRF_source_0, '0', freq_xlating_fft_filter_ccc_0_0, '0']
- [blocks_add_xx_0, '0', blocks_throttle_0_0, '0']
- [blocks_add_xx_0, '0', cdc_bladeRF_sink_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_sink_x_3, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_moving_average_xx_0_0, '0']
- [blocks_message_strobe_0, strobe, digital_crc32_async_bb_0, in]
- [blocks_message_strobe_0_0, strobe, digital_crc32_async_bb_0_0, in]
- [blocks_moving_average_xx_0, '0', epy_block_2, '0']
- [blocks_moving_average_xx_0, '0', qtgui_time_sink_x_3, '1']
- [blocks_moving_average_xx_0_0, '0', epy_block_2_0, '0']
- [blocks_multiply_const_vxx_0, '0', cdc_bladeRF_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', virtual_sink_1_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', cdc_bladeRF_sink_0_1, '0']
- [blocks_multiply_const_vxx_0_0, '0', virtual_sink_1_1, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_stream_to_tagged_stream_0, '0', digital_additive_scrambler_bb_0_0_0, '0']
- [blocks_stream_to_tagged_stream_0_1, '0', digital_additive_scrambler_bb_0_0_0_0, '0']
- [blocks_stream_to_tagged_stream_1, '0', digital_crc32_bb_1, '0']
- [blocks_stream_to_tagged_stream_1_0, '0', digital_crc32_bb_0, '0']
- [blocks_tagged_stream_mux_0, '0', digital_constellation_modulator_0, '0']
- [blocks_tagged_stream_mux_0_0, '0', digital_constellation_modulator_0_0, '0']
- [blocks_throttle_0_0, '0', zeromq_pub_sink_0_0, '0']
- [blocks_vector_source_x_0_0, '0', blocks_stream_to_tagged_stream_1, '0']
- [blocks_vector_source_x_0_0_0, '0', blocks_stream_to_tagged_stream_1_0, '0']
- [digital_additive_scrambler_bb_0_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [digital_additive_scrambler_bb_0_0_0, '0', digital_protocol_formatter_bb_0, '0']
- [digital_additive_scrambler_bb_0_0_0_0, '0', blocks_tagged_stream_mux_0_0, '1']
- [digital_additive_scrambler_bb_0_0_0_0, '0', digital_protocol_formatter_bb_0_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_constellation_modulator_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [digital_crc32_async_bb_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [digital_crc32_async_bb_0_0, out, pdu_pdu_to_tagged_stream_0_0, pdus]
- [digital_crc32_bb_0, '0', blocks_stream_to_tagged_stream_0_1, '0']
- [digital_crc32_bb_1, '0', blocks_stream_to_tagged_stream_0, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']
- [digital_protocol_formatter_bb_0_0, '0', blocks_tagged_stream_mux_0_0, '0']
- [epy_block_2, '0', blocks_null_sink_0, '0']
- [epy_block_2, msg_out, blocks_message_debug_0_0, print]
- [epy_block_2, msg_out, virtual_sink_0, '0']
- [epy_block_2_0, '0', blocks_null_sink_1, '0']
- [epy_block_2_0, msg_out, virtual_sink_1, '0']
- [freq_xlating_fft_filter_ccc_0, '0', blocks_complex_to_mag_squared_0, '0']
- [freq_xlating_fft_filter_ccc_0_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_stream_to_tagged_stream_0_1, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_multiply_xx_0_0, '0']
- [virtual_source_0, '0', digital_crc32_async_bb_0, in]
- [virtual_source_0_0, '0', rational_resampler_xxx_0_0, '0']
- [virtual_source_0_1, '0', rational_resampler_xxx_0, '0']
- [virtual_source_1, '0', digital_crc32_async_bb_0_0, in]

metadata:
  file_format: 1
