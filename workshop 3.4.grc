options:
  parameters:
    generate_options: qt_gui
    id: q
    output_language: python
    title: workshop 3.4
  states: {}

blocks:
- name: bps
  id: variable
  parameters:
    value: '1'
  states: {}
- name: constel_obj
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 2400*1000000
  states: {}
- name: header_format
  id: variable
  parameters:
    value: digital.header_format_default(preamble, threshold, bps)
  states: {}
- name: loop_bw_phase
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.001'
    stop: '0.35'
    value: '0.035'
  states: {}
- name: loop_bw_timing
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.001'
    stop: '0.35'
    value: '0.0157'
  states: {}
- name: modulated_sync_word
  id: variable
  parameters:
    value: np.array([(-0.3236511+0.38326213j),(-0.40872774+0.4129707j),(-0.4845583+0.37997225j),(-0.5032182+0.32404065j),(-0.41165453+0.29910493j),(-0.19140323+0.3406076j),(0.10448951+0.42875668j),(0.35776585+0.48820764j),(0.43999088+0.43321377j),(0.29857585+0.2238044j),(-0.0016923123-0.08678568j),(-0.30493987-0.36322355j),(-0.4475175-0.4616031j),(-0.3578216-0.31402352j),(-0.09209495+0.014918805j),(0.21060005+0.34843063j),(0.42208895+0.48991635j),(0.4896213+0.3480378j),(0.4486313-0.0024159108j),(0.37551832-0.35752875j),(0.3248284-0.5023269j),(0.30946657-0.34937963j),(0.31296533+0.0067436444j),(0.32001734+0.35203642j),(0.34035328+0.48583436j),(0.38160172+0.33988425j),(0.42816985+0.013239303j),(0.4384216-0.30044156j),(0.37184545-0.44174817j),(0.22137748-0.35834423j),(0.01804548-0.11132968j),(-0.185752+0.18075284j),(-0.34953737+0.40530214j),(-0.46069875+0.51281655j),(-0.5185853+0.5132632j),(-0.51158166+0.44026196j),(-0.40386286+0.3277593j),(-0.1798393+0.18640213j),(0.11326713+0.01687191j),(0.3639046-0.16836074j),(0.4455944-0.3456911j),(0.29753157-0.47543958j),(-0.016108027-0.52028054j),(-0.32668304-0.4689656j),(-0.46261698-0.3404056j),(-0.34330258-0.17003584j),(-0.031042483+0.008681094j),(0.30258363+0.17916662j),(0.46881175+0.32919857j),(0.38078758+0.44964597j),(0.09522163+0.52000684j),(-0.23234767+0.50608927j),(-0.44938833+0.38737035j),(-0.49435654+0.17034389j),(-0.41517287-0.09328418j),(-0.3205732-0.31230974j),(-0.29131326-0.40150824j),(-0.34087446-0.3159915j),(-0.41880548-0.08198235j),(-0.45265406+0.2069943j),(-0.38737032+0.42617095j),(-0.22377913+0.49777487j),(-0.009854655+0.43297607j),(0.19706434+0.31843114j),(0.35833743+0.26424968j),(0.45907328+0.3184311j),(0.4986024+0.4349135j),(0.47110766+0.5042489j),(0.3674692+0.4314565j),(0.19247924+0.20531921j),(-0.024789115-0.09211061j),(-0.23076144-0.32970107j),(-0.37328473-0.40535447j),(-0.431186-0.30125067j),(-0.42191654-0.08028718j),(-0.38640052+0.16437826j),(-0.3509243+0.3627137j),(-0.3248162+0.4879715j),(-0.30864936+0.54143703j),(-0.30870503+0.5161171j),(-0.3315532+0.39121655j),(-0.3832272+0.1629665j),(-0.44815278-0.12145794j),(-0.4788955-0.35594255j),(-0.40823913-0.42622328j),(-0.20873754-0.28620908j),(0.07043252+6.0535967e-09j),(0.31889516+0.2862091j),(0.42184705+0.4262233j),(0.32704428+0.35594258j),(0.08056081+0.12339542j),(-0.20150197-0.15649253j),(-0.40967843-0.38593107j),(-0.4882795-0.5177922j),(-0.452959-0.5496278j),(-0.370026-0.49520707j),(-0.30833587-0.36127442j),(-0.2999712-0.15499425j),(-0.33294827+0.08896827j),(-0.3716122+0.30099744j),(-0.38443947+0.39270815j),(-0.36314175+0.31761697j),(-0.32814205+0.10196527j),(-0.3122589-0.16652036j),(-0.33011392-0.38977727j),(-0.37752494-0.51041484j),(-0.42913863-0.52436024j),(-0.44573534-0.46128526j),(-0.38472754-0.3444876j),(-0.2282984-0.18226397j),(-0.0016794971+0.016365988j),(0.23333398+0.22292504j),(0.40050048+0.38256863j),(0.45461327+0.44788605j),(0.40987924+0.4166229j),(0.32967448+0.33905846j),(0.29163128+0.29307055j),(0.33206883+0.32483327j),(0.41890198+0.41071117j),(0.47003168+0.46835655j),(0.41165453+0.41694003j),(0.22458975+0.23106374j),(-0.038833216-0.036895767j),(-0.281107-0.281107j),(-0.40797108-0.40797108j),(-0.38355297-0.38355297j),(-0.24617451-0.24617451j),(-0.080319144-0.080319144j)],dtype=np.complex64)
  states: {}
- name: modulated_sync_word_8
  id: variable
  parameters:
    value: np.array([(-0.3236511+0.38326213j),(-0.40872774+0.4129707j),(-0.4845583+0.37997225j),(-0.5032182+0.32404065j),(-0.41165453+0.29910493j),(-0.19140323+0.3406076j),(0.10448951+0.42875668j),(0.35776585+0.48820764j),(0.43999088+0.43321377j),(0.29857585+0.2238044j),(-0.0016923123-0.08678568j),(-0.30493987-0.36322355j),(-0.4475175-0.4616031j),(-0.3578216-0.31402352j),(-0.09209495+0.014918805j),(0.21060005+0.34843063j),(0.42208895+0.48991635j),(0.4896213+0.3480378j),(0.4486313-0.0024159108j),(0.37551832-0.35752875j),(0.3248284-0.5023269j),(0.30946657-0.34937963j),(0.31296533+0.0067436444j),(0.32001734+0.35203642j),(0.34035328+0.48583436j),(0.38160172+0.33988425j),(0.42816985+0.013239303j),(0.4384216-0.30044156j),(0.37184545-0.44174817j),(0.22137748-0.35834423j),(0.01804548-0.11132968j),(-0.185752+0.18075284j),(-0.34953737+0.40530214j),(-0.46069875+0.51281655j),(-0.5185853+0.5132632j),(-0.51158166+0.44026196j),(-0.40386286+0.3277593j),(-0.1798393+0.18640213j),(0.11326713+0.01687191j),(0.3639046-0.16836074j),(0.4455944-0.3456911j),(0.29753157-0.47543958j),(-0.016108027-0.52028054j),(-0.32668304-0.4689656j),(-0.46261698-0.3404056j),(-0.34330258-0.17003584j),(-0.031042483+0.008681094j),(0.30258363+0.17916662j),(0.46881175+0.32919857j),(0.38078758+0.44964597j),(0.09522163+0.52000684j),(-0.23234767+0.50608927j),(-0.44938833+0.38737035j),(-0.49435654+0.17034389j),(-0.41517287-0.09328418j),(-0.3205732-0.31230974j),(-0.29131326-0.40150824j),(-0.34087446-0.3159915j),(-0.41880548-0.08198235j),(-0.45265406+0.2069943j),(-0.38737032+0.42617095j),(-0.22377913+0.49777487j),(-0.009854655+0.43297607j),(0.19706434+0.31843114j),(0.35833743+0.26424968j),(0.45907328+0.3184311j),(0.4986024+0.4349135j),(0.47110766+0.5042489j),(0.3674692+0.4314565j),(0.19247924+0.20531921j),(-0.024789115-0.09211061j),(-0.23076144-0.32970107j),(-0.37328473-0.40535447j),(-0.431186-0.30125067j),(-0.42191654-0.08028718j),(-0.38640052+0.16437826j),(-0.3509243+0.3627137j),(-0.3248162+0.4879715j),(-0.30864936+0.54143703j),(-0.30870503+0.5161171j),(-0.3315532+0.39121655j),(-0.3832272+0.1629665j),(-0.44815278-0.12145794j),(-0.4788955-0.35594255j),(-0.40823913-0.42622328j),(-0.20873754-0.28620908j),(0.07043252+6.0535967e-09j),(0.31889516+0.2862091j),(0.42184705+0.4262233j),(0.32704428+0.35594258j),(0.08056081+0.12339542j),(-0.20150197-0.15649253j),(-0.40967843-0.38593107j),(-0.4882795-0.5177922j),(-0.452959-0.5496278j),(-0.370026-0.49520707j),(-0.30833587-0.36127442j),(-0.2999712-0.15499425j),(-0.33294827+0.08896827j),(-0.3716122+0.30099744j),(-0.38443947+0.39270815j),(-0.36314175+0.31761697j),(-0.32814205+0.10196527j),(-0.3122589-0.16652036j),(-0.33011392-0.38977727j),(-0.37752494-0.51041484j),(-0.42913863-0.52436024j),(-0.44573534-0.46128526j),(-0.38472754-0.3444876j),(-0.2282984-0.18226397j),(-0.0016794971+0.016365988j),(0.23333398+0.22292504j),(0.40050048+0.38256863j),(0.45461327+0.44788605j),(0.40987924+0.4166229j),(0.32967448+0.33905846j),(0.29163128+0.29307055j),(0.33206883+0.32483327j),(0.41890198+0.41071117j),(0.47003168+0.46835655j),(0.41165453+0.41694003j),(0.22458975+0.23106374j),(-0.038833216-0.036895767j),(-0.281107-0.281107j),(-0.40797108-0.40797108j),(-0.38355297-0.38355297j),(-0.24617451-0.24617451j),(-0.080319144-0.080319144j)],dtype=np.complex64)
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: preamble
  id: variable
  parameters:
    value: digital.packet_utils.default_access_code
  states: {}
- name: rrc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: excess_bw
    gain: nfilts
    ntaps: 11*sps*nfilts
    samp_rate: sps*nfilts
    sym_rate: '1.0'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0, 1, 1, 1
    label: Rx Gain (dB)
    start: '-24'
    step: '1'
    stop: '66'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1100000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: symb_rate
  id: variable
  parameters:
    value: '275000'
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '3'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0, 0, 1, 1
    label: Tx Gain (dB)
    start: '-24'
    step: '1'
    stop: '66'
    value: '30'
  states: {}
- name: analog_feedforward_agc_cc_1
  id: analog_feedforward_agc_cc
  parameters:
    num_samples: '64'
    reference: '1.5'
  states: {state: disabled}
- name: blocks_multiply_by_tag_value_cc_0
  id: blocks_multiply_by_tag_value_cc
  parameters:
    tagname: chan_est_inv
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.25'
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_MSB_FIRST
    k: '2'
    l: '1'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '64'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_uchar_to_float_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_1_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (57,12,140,125,114,71,52,44,216,16,15,47,111,119,13,101,214,112,229,142,3,81,216,174,142,79,110,172,52,47,194,49,183,176,135,22,235,63,193,40,150,185,98,35,23,116,148,40,119,51,194,142,232,186,83,189,181,107,136,36,87,125,83,236)
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (57,12,140,125,114,71,52,44,216,16,15,47,111,119,13,101,214,112,229,142,3,81,216,174,142,79,110,172,52,47,194,49,183,176,135,22,235,63,193,40,150,185,98,35,23,116,148,40,119,51,194,142,232,186,83,189,181,107,136,36,87,125,83,236)
  states: {}
- name: cdc_bladeRF_sink_0
  id: cdc_bladeRF_sink
  parameters:
    buffers: '16'
    buflen: '8192'
    bw: '0'
    device_id: '0'
    freq: freq
    gain0: rx_gain
    gain1: '10'
    metadata: 'False'
    nchan: '1'
    sample_rate: samp_rate
    transfers: '8'
    verbosity: warning
  states: {}
- name: cdc_bladeRF_source_0
  id: cdc_bladeRF_source
  parameters:
    buffers: '16'
    buflen: '8192'
    bw: '0'
    dc_offset_mode0: '0'
    dc_offset_mode1: '0'
    device_id: '0'
    freq: freq
    gain0: tx_gain
    gain1: '10'
    gain_mode0: 'False'
    gain_mode1: 'False'
    iq_balance_mode0: '0'
    iq_balance_mode1: '0'
    metadata: 'False'
    nchan: '1'
    sample_rate: samp_rate
    transfers: '8'
    verbosity: warning
  states: {}
- name: cdc_preamble_detect_cc_0
  id: cdc_preamble_detect_cc
  parameters:
    mark_delay: '1'
    sequence: modulated_sync_word
    threshold: '0.5'
  states: {}
- name: digital_constellation_decoder_cb_1
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constel_obj
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: constel_obj
    differential: 'False'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: preamble
    tagname: '"packet_len"'
    threshold: threshold
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: loop_bw_phase
  states: {}
- name: digital_diff_decoder_bb_1
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {state: bypassed}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: header_format
    len_tag_key: '"packet_len"'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: loop_bw_timing
    max_dev: '1.5'
    nfilters: nfilts
    osps: '1'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_EARLY_LATE
    type: cc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"bytes"'
    nconnections: '2'
    size: '64'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: float
    ymax: '256'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2, 0, 1, 2
    name: '"Preamble Correlation"'
    size: '256'
    srate: '1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"corr_est"'
    type: float
    ymax: '1.5'
    ymin: '0'
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: rx_
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: rx_
  states: {}

connections:
- [analog_feedforward_agc_cc_1, '0', digital_symbol_sync_xx_0, '0']
- [blocks_multiply_by_tag_value_cc_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', cdc_bladeRF_sink_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_uchar_to_float_1, '0']
- [blocks_repack_bits_bb_0_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '1']
- [blocks_stream_to_tagged_stream_0, '0', digital_protocol_formatter_bb_0, '0']
- [blocks_tagged_stream_mux_0, '0', digital_constellation_modulator_0, '0']
- [blocks_uchar_to_float_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_uchar_to_float_1_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_vector_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_vector_source_x_0_0, '0', blocks_uchar_to_float_1_0, '0']
- [cdc_bladeRF_source_0, '0', analog_feedforward_agc_cc_1, '0']
- [cdc_bladeRF_source_0, '0', cdc_preamble_detect_cc_0, '0']
- [cdc_preamble_detect_cc_0, '0', blocks_multiply_by_tag_value_cc_0, '0']
- [cdc_preamble_detect_cc_0, '1', qtgui_time_sink_x_0_0, '0']
- [digital_constellation_decoder_cb_1, '0', digital_diff_decoder_bb_1, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0, '0', virtual_sink_1, '0']
- [digital_diff_decoder_bb_1, '0', blocks_repack_bits_bb_0_0, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [virtual_source_0, '0', digital_constellation_decoder_cb_1, '0']

metadata:
  file_format: 1
